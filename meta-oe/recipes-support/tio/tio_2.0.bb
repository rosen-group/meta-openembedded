require tio.inc
SRC_URI = "git://github.com/tio/tio;protocol=https;nobranch=1"
SRCREV = "6618642acf28fec6d3e70ed75b50d4ce138ea08a"
